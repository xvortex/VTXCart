# IAR project cart.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750xx; USE_HAL_DRIVER; NDEBUG
  ICCARM.CCIncludePath2: Drivers\CMSIS\Inc; Drivers\HAL\Inc; Drivers\BSP\Inc; Libraries\FatFs; Libraries\USB\Inc; User\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cart.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Flash\WEACT.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    Drivers/BSP/Src/: st7735.c st7735_reg.c weact_bsp.c weact_sd.c
  group Drivers/CMSIS
    Drivers/CMSIS/Startup/: startup_stm32h750xx.s
  group Drivers/HAl
    Drivers/HAL/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_spi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Libraries/FatFs
    Libraries/FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c sd_diskio.c
  group Libraries/USB
    Libraries/USB/Src/: usbd_cdc.c usbd_cdc_if.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group User
    User/Src/: CV.c fatfs.c font32.c lcd.c main.c P.c SM.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c tools.c uart.c usb_device.c variables.c
